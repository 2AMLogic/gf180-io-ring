v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 20 60 0 0 {name=p1 lab=DVDD}
C {devices/iopin.sym} 20 90 0 0 {name=p2 lab=DVSS}
C {devices/iopin.sym} 20 120 0 0 {name=p3 lab=VDD}
C {devices/iopin.sym} 20 150 0 0 {name=p4 lab=VSS}
T {corner cell: rail-only, no devices. DVDD/DVSS/VDD/VSS continuous through the abutting ports.} 20 10 0 0 0.4 0.4 {}
